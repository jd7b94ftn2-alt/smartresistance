#include "ui.h"

#include <TFT_eSPI.h>

#include <algorithm>
#include <cmath>
#include <ctime>
#include <utility>

#include "app.h"
#include "board_pins.h"
#include "comm.h"
#include "font_zh16.h"
#include "font_zh24.h"
#include "messages.h"

namespace ui {
namespace {

TFT_eSPI tft;

constexpr int kWidth = 320;
constexpr int kHeight = 240;
constexpr int kBar = 26;
constexpr std::uint32_t kLongPressMs = 600;
constexpr std::uint32_t kDebounceMs = 25;
constexpr std::uint32_t kRefreshMs = 150;
constexpr std::uint32_t kTouchPollMs = 20;
constexpr std::uint16_t kTouchPressure = 400;
constexpr int kBacklightChannel = 0;

// 0xRRGGBB -> RGB565
constexpr std::uint16_t rgb(std::uint32_t hex) {
    return static_cast<std::uint16_t>(((hex >> 8) & 0xF800) | ((hex >> 5) & 0x07E0) | ((hex >> 3) & 0x001F));
}

// Dark slate theme, same palette as the PC host program.
constexpr std::uint16_t kBg = rgb(0x0B1220);
constexpr std::uint16_t kCard = rgb(0x172133);       // panels behind digits / home tiles
constexpr std::uint16_t kButton = rgb(0x25334D);
constexpr std::uint16_t kBorder = rgb(0x2A3A58);
constexpr std::uint16_t kFg = rgb(0xE5E9F0);
constexpr std::uint16_t kDim = rgb(0x8B97AB);
constexpr std::uint16_t kAccent = rgb(0x2A9DF4);     // focus, selection
constexpr std::uint16_t kBarColor = rgb(0x111A2B);
constexpr std::uint16_t kOnColor = rgb(0x16A34A);
constexpr std::uint16_t kOffColor = rgb(0xB91C1C);
constexpr std::uint16_t kBlue = kAccent;
constexpr std::uint16_t kInfo = rgb(0x5CC8FF);       // highlighted values
constexpr std::uint16_t kGood = rgb(0x4ADE80);
constexpr std::uint16_t kWarn = rgb(0xFBBF24);
constexpr std::uint16_t kBad = rgb(0xF87171);
constexpr std::uint16_t kWhite = rgb(0xFFFFFF);

// ------------------------------------------------------------ language
const char* tr(const char* zh, const char* en) {
    return app::settings().language == 1 ? en : zh;
}

// ------------------------------------------------------------ fonts
// Two anti-aliased fonts (16 / 24 px, generated by tools/make_fonts.py with only the glyphs this
// file uses) plus the built-in fonts: 1 = 6x8, 7 = 7-segment digits. TFT_eSPI holds one smooth
// font at a time, so useFont() swaps on demand; parsing the metrics takes well under 1 ms.
enum class Font : std::uint8_t { Builtin, Small, Large };
Font loadedFont = Font::Builtin;

void useFont(Font font) {
    if (font == loadedFont) {
        return;
    }
    if (loadedFont != Font::Builtin) {
        tft.unloadFont();
    }
    if (font == Font::Small) {
        tft.loadFont(kFontZh16);
    } else if (font == Font::Large) {
        tft.loadFont(kFontZh24);
    }
    loadedFont = font;
}

void text(const String& value, int x, int y, Font font, std::uint16_t fg, std::uint16_t bg, int padding,
    std::uint8_t datum, int builtinFont) {
    useFont(font);
    tft.setTextDatum(datum);
    tft.setTextColor(fg, bg, true);
    tft.setTextPadding(padding);
    if (font == Font::Builtin) {
        tft.drawString(value, x, y, builtinFont);
    } else {
        tft.drawString(value, x, y);
    }
}

// ------------------------------------------------------------ widgets with a redraw cache
// Every widget has a slot id; it is repainted only when its text or style changed, which keeps
// the 150 ms refresh flicker-free. Slots are cleared whenever a page is (re)entered.
constexpr int kSlots = 64;
String slotText[kSlots];
std::uint32_t slotKey[kSlots];

void resetSlots() {
    for (int i = 0; i < kSlots; ++i) {
        slotText[i] = "\x01";
        slotKey[i] = 0xFFFFFFFF;
    }
}

bool changed(int id, const String& value, std::uint32_t key) {
    if (slotKey[id] == key && slotText[id] == value) {
        return false;
    }
    slotText[id] = value;
    slotKey[id] = key;
    return true;
}

struct Rect {
    std::int16_t x;
    std::int16_t y;
    std::int16_t w;
    std::int16_t h;

    bool contains(int px, int py) const {
        return px >= x && px < x + w && py >= y && py < y + h;
    }
};

enum class Style : std::uint8_t { Normal, Selected, On, Off, Accent, Disabled, Muted };

// Anti-aliased rounded panel. The background colour is always passed so TFT_eSPI never has to read
// pixels back from the display.
void panel(int x, int y, int w, int h, int radius, std::uint16_t fill, std::uint16_t bg = kBg) {
    tft.fillSmoothRoundRect(x, y, w, h, radius, fill, bg);
}

int buttonRadius(const Rect& r) {
    return r.h >= 30 ? 10 : r.h / 2;
}

void button(int id, const Rect& r, const String& label, Style style, Font font, bool focused,
    std::uint16_t bg = kBg) {
    const std::uint32_t key = static_cast<std::uint32_t>(style) | (static_cast<std::uint32_t>(font) << 4)
        | (focused ? 0x100U : 0U) | (static_cast<std::uint32_t>(r.x) << 12) | (static_cast<std::uint32_t>(r.y) << 22);
    if (!changed(id, label, key)) {
        return;
    }
    std::uint16_t fill = kButton;
    std::uint16_t fg = kFg;
    switch (style) {
        case Style::Selected: fill = kAccent; fg = kWhite; break;
        case Style::On: fill = kOnColor; fg = kWhite; break;
        case Style::Off: fill = kOffColor; fg = kWhite; break;
        case Style::Accent: fill = kBlue; fg = kWhite; break;
        case Style::Disabled: fill = kCard; fg = kBorder; break;
        case Style::Muted: fg = kDim; break;
        default: break;
    }
    const int radius = buttonRadius(r);
    tft.fillRect(r.x, r.y, r.w, r.h, bg);
    if (focused) {
        // 2 px accent ring: outer accent shape, then the button face inset by 2 px.
        panel(r.x, r.y, r.w, r.h, radius, kAccent, bg);
        panel(r.x + 2, r.y + 2, r.w - 4, r.h - 4, std::max(1, radius - 2), fill, kAccent);
    } else {
        panel(r.x, r.y, r.w, r.h, radius, fill, bg);
    }
    text(label, r.x + r.w / 2, r.y + r.h / 2 + 1, font, fg, fill, 0, MC_DATUM, 2);
}

void label(int id, int x, int y, int width, const String& value, Font font, std::uint16_t fg,
    std::uint8_t datum = TL_DATUM, std::uint16_t bg = kBg) {
    if (!changed(id, value, (static_cast<std::uint32_t>(fg) << 8) | static_cast<std::uint32_t>(font)
            | (static_cast<std::uint32_t>(bg) << 24))) {
        return;
    }
    text(value, x, y, font, fg, bg, width, datum, 2);
}

// Built-in 7-segment font for large numbers (font 7: 0-9 . - : only).
void bigNumber(int id, int x, int y, int width, const String& value, std::uint16_t fg, std::uint8_t datum,
    std::uint16_t bg = kBg) {
    if (!changed(id, value, fg)) {
        return;
    }
    text(value, x, y, Font::Builtin, fg, bg, width, datum, 7);
}

// ------------------------------------------------------------ encoder
volatile std::int32_t encoderRaw = 0;
volatile std::uint8_t encoderState = 0;

void IRAM_ATTR onEncoderEdge() {
    // Gray-code transition table: +1 / -1 for valid steps, 0 for bounce.
    static const DRAM_ATTR std::int8_t table[16] = {0, -1, 1, 0, 1, 0, 0, -1, -1, 0, 0, 1, 0, 1, -1, 0};
    const std::uint8_t now = static_cast<std::uint8_t>(
        (digitalRead(board::kEncoderA) << 1) | digitalRead(board::kEncoderB));
    encoderState = static_cast<std::uint8_t>(((encoderState << 2) | now) & 0x0F);
    encoderRaw += table[encoderState];
}

// EC11E18244A5: four transitions per detent.
int takeEncoderSteps() {
    static std::int32_t consumed = 0;
    noInterrupts();
    const std::int32_t raw = encoderRaw;
    interrupts();
    const std::int32_t steps = (raw - consumed) / 4;
    consumed += steps * 4;
    return static_cast<int>(steps);
}

enum class Press : std::uint8_t { None, Short, Long };

Press pollButton() {
    static bool stable = false;
    static bool lastRaw = false;
    static bool longFired = false;
    static std::uint32_t changeMs = 0;
    static std::uint32_t downMs = 0;

    const std::uint32_t now = millis();
    const bool raw = digitalRead(board::kEncoderSwitch) == LOW;
    if (raw != lastRaw) {
        lastRaw = raw;
        changeMs = now;
    }
    if (now - changeMs >= kDebounceMs && raw != stable) {
        stable = raw;
        if (stable) {
            downMs = now;
            longFired = false;
        } else if (!longFired) {
            return Press::Short;
        }
    }
    if (stable && !longFired && now - downMs >= kLongPressMs) {
        longFired = true;
        return Press::Long;
    }
    return Press::None;
}

// ------------------------------------------------------------ touch
bool readTouchRaw(std::uint16_t& x, std::uint16_t& y, std::uint16_t& z) {
    x = 0;
    y = 0;
    z = tft.getTouchRawZ();
    if (z < kTouchPressure) {
        return false;
    }
    std::uint32_t sumX = 0;
    std::uint32_t sumY = 0;
    for (int i = 0; i < 4; ++i) {
        std::uint16_t rx = 0;
        std::uint16_t ry = 0;
        tft.getTouchRaw(&rx, &ry);
        sumX += rx;
        sumY += ry;
    }
    if (tft.getTouchRawZ() < kTouchPressure) {
        return false;
    }
    x = static_cast<std::uint16_t>(sumX / 4);
    y = static_cast<std::uint16_t>(sumY / 4);
    // A floating MISO (touch not wired) reads all zeros or all ones.
    return x > 20 && x < 4075 && y > 20 && y < 4075;
}

void mapTouch(std::uint16_t rx, std::uint16_t ry, int& x, int& y) {
    const app::Settings& config = app::settings();
    const float* c = config.touchCal;
    float fx = c[0] * rx + c[1] * ry + c[2];
    float fy = c[3] * rx + c[4] * ry + c[5];
    if (config.rotation != config.touchRotation) {
        fx = kWidth - 1 - fx;
        fy = kHeight - 1 - fy;
    }
    x = std::min(kWidth - 1, std::max(0, static_cast<int>(lroundf(fx))));
    y = std::min(kHeight - 1, std::max(0, static_cast<int>(lroundf(fy))));
}

// ------------------------------------------------------------ state
Page currentPage = Page::Menu;
Page requestedPage = Page::Resistor;
Page returnPage = Page::Resistor;     // where the home cursor sits / where calibration returns
bool pageChangePending = true;
bool bootChecked = false;
bool dirty = true;
std::uint32_t lastRefreshMs = 0;

int homeIndex = 0;
int resistorField = 5;     // 0..5 = digits (100k .. 1), 6 = output
int ntcField = 1;          // 0 type, 1 +-1, 2 +-0.1, 3 output
double ntcEditTemp = 25.0;
int bleField = 0;          // 0 mode, 1 on/off
bool knobArmed = false;
int relayField = 0;        // 0 relay, 1 on, 2 off, 3 count, 4 run
int relayIndex = 0;
std::uint32_t relayOnMs = 200;
std::uint32_t relayOffMs = 200;
std::uint32_t relayCount = 100;
int settingsField = 0;     // 0 backlight, 1 flip, 2 language, 3 touch calibration
int msgScroll = 0;         // index of the top card on the Messages page
std::uint32_t bridgeDrawnRev = 0xFFFFFFFF;
int tempDrawnCount = -1;

// touch tap / auto-repeat
std::uint32_t lastTouchPollMs = 0;
int touchDownCount = 0;
bool touchHeld = false;
bool touchRepeat = false;
int tapX = 0;
int tapY = 0;
std::uint32_t nextRepeatMs = 0;

// calibration
const int kCalX[4] = {20, kWidth - 21, kWidth - 21, 20};
const int kCalY[4] = {20, 20, kHeight - 21, kHeight - 21};
int calStep = 0;
int calSamples = 0;
std::uint32_t calSumX = 0;
std::uint32_t calSumY = 0;
bool calWaitRelease = false;
int calReleaseCount = 0;
float calRawX[4];
float calRawY[4];

struct HomeEntry {
    const char* zh;
    const char* en;
    const char* zhSub;
    const char* enSub;
    Page page;
    std::uint16_t color;
};

const HomeEntry kHome[] = {
    {"电阻", "Ohm", "0~999kΩ", "0~999kΩ", Page::Resistor, rgb(0x2A9DF4)},
    {"NTC", "NTC", "温度模拟", "Temp sim", Page::Ntc, rgb(0x22C55E)},
    {"蓝牙", "BLE", "连接/透传", "Link/UART", Page::Bluetooth, rgb(0x6366F1)},
    {"旋钮", "Knob", "USB 键鼠", "USB HID", Page::Knob, rgb(0xA855F7)},
    {"串口", "UART", "J_DBG 监视", "J_DBG log", Page::Serial, rgb(0xF97316)},
    {"曲线", "Log", "板温记录", "Board temp", Page::TempLog, rgb(0x14B8A6)},
    {"时钟", "Clock", "时钟/消息", "Clock/Msg", Page::Info, rgb(0xEC4899)},
    {"继电器", "Relay", "循环测试", "Cycle test", Page::RelayTest, rgb(0xEF4444)},
    {"设置", "Setup", "背光/触摸", "Light/Touch", Page::About, rgb(0x94A3B8)},
};
constexpr int kHomeCount = sizeof(kHome) / sizeof(kHome[0]);

const std::uint32_t kBaudRates[] = {9600, 19200, 38400, 57600, 115200, 230400, 460800, 921600};
constexpr int kBaudCount = sizeof(kBaudRates) / sizeof(kBaudRates[0]);
const std::uint16_t kLogIntervals[] = {1, 2, 5, 10, 30, 60};
constexpr int kLogIntervalCount = sizeof(kLogIntervals) / sizeof(kLogIntervals[0]);

int wrap(int value, int count) {
    return ((value % count) + count) % count;
}

std::uint32_t stepClamped(std::uint32_t value, int steps, std::uint32_t stepSize, std::uint32_t low,
    std::uint32_t high) {
    const std::int64_t next = static_cast<std::int64_t>(value) + static_cast<std::int64_t>(steps) * stepSize;
    return static_cast<std::uint32_t>(std::min<std::int64_t>(high, std::max<std::int64_t>(low, next)));
}

const char* pageTitle(Page page) {
    switch (page) {
        case Page::Menu: return tr("智能电阻箱", "SmartResistance");
        case Page::Resistor: return tr("电阻", "Resistor");
        case Page::Ntc: return tr("NTC 温度", "NTC");
        case Page::Bluetooth: return tr("蓝牙", "Bluetooth");
        case Page::Knob: return tr("USB 旋钮", "USB knob");
        case Page::Serial: return tr("串口监视", "Serial");
        case Page::TempLog: return tr("温度曲线", "Temp log");
        case Page::Info: return tr("信息时钟", "Info");
        case Page::RelayTest: return tr("继电器测试", "Relay test");
        case Page::About: return tr("设置", "Settings");
        case Page::Messages: return tr("消息", "Messages");
        default: return "";
    }
}

String relayName(int index) {
    static const char* const weights[] = {
        "10R", "20R", "40R", "80R", "100R", "200R", "400R", "800R", "1K", "2K",
        "4K", "8K", "10K", "20K", "40K", "80K", "100K", "200K", "400K", "800K",
    };
    static const char* const bypass[] = {"GE10", "GE100", "GE1K", "GE10K", "GE100K"};
    if (index < 9) {
        return "K_U" + String(index + 1);
    }
    if (index == 9) {
        return "K_U0";
    }
    if (index < 30) {
        return String("K_") + weights[index - 10];
    }
    if (index < 35) {
        return String("K_BYP_") + bypass[index - 30];
    }
    if (index == 35) {
        return "K_SHORT";
    }
    if (index < 40) {
        return "SPARE" + String(index);
    }
    return "K_OUT";
}

const char* knobModeLabel(int mode) {
    switch (mode) {
        case 0: return tr("音量", "Volume");
        case 1: return tr("滚轮", "Scroll");
        case 2: return tr("切歌", "Media");
        case 3: return tr("方向键", "Arrows");
        default: return "?";
    }
}

String ntcTypeName(int index) {
    return index == app::ntcTypeCount() - 1 ? String(tr("自定义", "User")) : String(app::ntcName(index));
}

void goHome() {
    returnPage = currentPage;
    requestedPage = Page::Menu;
    pageChangePending = true;
}

// ------------------------------------------------------------ status bar
enum : int { kSlotBack = 56, kSlotTitle, kSlotStatus, kSlotOut };

void thickLine(float x0, float y0, float x1, float y1, std::uint16_t color, std::uint16_t bg, float width = 2.0f) {
    tft.drawWideLine(x0, y0, x1, y1, width, color, bg);
}

void drawBackButton() {
    if (!changed(kSlotBack, tr("返回", "Back"), 0)) {
        return;
    }
    const Rect r = {3, 3, 62, 20};
    tft.fillRect(r.x, r.y, r.w, r.h, kBarColor);
    panel(r.x, r.y, r.w, r.h, 10, kButton, kBarColor);
    thickLine(16, 13, 11, 8, kFg, kButton);
    thickLine(11, 13, 16, 18, kFg, kButton);
    text(tr("返回", "Back"), 21, 13, Font::Small, kFg, kButton, 0, ML_DATUM, 2);
}

void drawStatusBar() {
    const bool home = currentPage == Page::Menu;
    if (!home) {
        drawBackButton();
    }
    label(kSlotTitle, home ? 8 : 72, 5, 92, pageTitle(currentPage), Font::Small, kFg, TL_DATUM, kBarColor);

    String right;
    std::uint16_t rightColor = kDim;
    if (msg::unread() > 0 && currentPage != Page::Messages) {
        right = String(tr("新消息 ", "New ")) + String(msg::unread());     // tap here to open the list
        rightColor = kWarn;
    } else {
        if (app::tempValid()) {
            right += String(app::boardTempC(), 1) + "°C ";
        }
        right += comm::wifiConnected() ? "WiFi " : (comm::accessPointActive() ? "AP " : "");
        right += comm::bleConnected() ? "BT" : "";
    }
    label(kSlotStatus, 262, 5, 90, right, Font::Small, rightColor, TR_DATUM, kBarColor);

    const auto& st = app::state();
    button(kSlotOut, Rect{268, 4, 48, 18}, st.fault ? "ERR" : (st.outputEnabled ? "ON" : "OFF"),
        st.fault ? Style::Off : (st.outputEnabled ? Style::On : Style::Muted), Font::Small, false, kBarColor);
}

// ------------------------------------------------------------ pages
// Layout constants shared by rendering and touch handling.
int digitX(int i) {
    return 18 + i * 40 + (i >= 3 ? 12 : 0);
}
const Rect kOutputButton = {10, 196, 300, 38};

Rect homeTile(int i) {
    return Rect{static_cast<std::int16_t>(4 + (i % 3) * 106), static_cast<std::int16_t>(30 + (i / 3) * 70), 102, 66};
}

// Small line icons for the home tiles, drawn around (cx, cy) in about 18 x 18 px.
void homeIcon(int index, int cx, int cy, std::uint16_t c, std::uint16_t bg) {
    switch (index) {
        case 0:   // resistor zig-zag
            thickLine(cx - 9, cy, cx - 6, cy, c, bg);
            for (int k = 0; k < 4; ++k) {
                thickLine(cx - 6 + k * 3, cy + (k % 2 ? 4 : -4), cx - 3 + k * 3, cy + (k % 2 ? -4 : 4), c, bg);
            }
            thickLine(cx + 6, cy + 4, cx + 9, cy, c, bg);
            break;
        case 1:   // thermometer
            tft.drawRoundRect(cx - 3, cy - 9, 7, 13, 3, c);
            tft.fillSmoothCircle(cx, cy + 6, 5, c, bg);
            break;
        case 2:   // Bluetooth rune
            thickLine(cx - 5, cy - 4, cx + 4, cy + 4, c, bg);
            thickLine(cx + 4, cy + 4, cx, cy + 8, c, bg);
            thickLine(cx, cy + 8, cx, cy - 8, c, bg);
            thickLine(cx, cy - 8, cx + 4, cy - 4, c, bg);
            thickLine(cx + 4, cy - 4, cx - 5, cy + 4, c, bg);
            break;
        case 3:   // knob
            tft.drawSmoothCircle(cx, cy, 8, c, bg);
            tft.drawSmoothCircle(cx, cy, 7, c, bg);
            thickLine(cx, cy, cx + 4, cy - 5, c, bg);
            break;
        case 4:   // terminal
            tft.drawRoundRect(cx - 9, cy - 7, 19, 15, 3, c);
            thickLine(cx - 5, cy - 3, cx - 1, cy, c, bg);
            thickLine(cx - 1, cy, cx - 5, cy + 3, c, bg);
            thickLine(cx + 1, cy + 3, cx + 5, cy + 3, c, bg);
            break;
        case 5:   // chart
            thickLine(cx - 9, cy + 6, cx - 4, cy - 1, c, bg);
            thickLine(cx - 4, cy - 1, cx, cy + 3, c, bg);
            thickLine(cx, cy + 3, cx + 5, cy - 6, c, bg);
            thickLine(cx + 5, cy - 6, cx + 9, cy - 3, c, bg);
            break;
        case 6:   // clock
            tft.drawSmoothCircle(cx, cy, 8, c, bg);
            tft.drawSmoothCircle(cx, cy, 7, c, bg);
            thickLine(cx, cy - 5, cx, cy, c, bg);
            thickLine(cx, cy, cx + 4, cy + 2, c, bg);
            break;
        case 7:   // relay: coil and contact
            tft.drawRect(cx - 8, cy - 3, 6, 10, c);
            thickLine(cx, cy + 6, cx + 7, cy - 4, c, bg);
            tft.fillSmoothCircle(cx + 7, cy + 6, 2, c, bg);
            break;
        default:  // gear
            for (int k = 0; k < 8; ++k) {
                const float a = k * 0.785398f;
                thickLine(cx + 6 * cosf(a), cy + 6 * sinf(a), cx + 9 * cosf(a), cy + 9 * sinf(a), c, bg, 3.0f);
            }
            tft.drawSmoothCircle(cx, cy, 6, c, bg);
            tft.drawSmoothCircle(cx, cy, 5, c, bg);
            break;
    }
}

void renderHome() {
    for (int i = 0; i < kHomeCount; ++i) {
        const Rect r = homeTile(i);
        const HomeEntry& e = kHome[i];
        const bool selected = i == homeIndex;
        if (!changed(i, tr(e.zh, e.en), selected ? 1 : 0)) {
            continue;
        }
        tft.fillRect(r.x, r.y, r.w, r.h, kBg);
        if (selected) {
            panel(r.x, r.y, r.w, r.h, 9, kAccent);
            panel(r.x + 2, r.y + 2, r.w - 4, r.h - 4, 7, kCard, kAccent);
        } else {
            panel(r.x, r.y, r.w, r.h, 9, kCard);
        }
        tft.fillSmoothRoundRect(r.x + 3, r.y + 12, 4, r.h - 24, 2, e.color, kCard);     // colour strip
        text(tr(e.zh, e.en), r.x + 12, r.y + 23, Font::Large, kFg, kCard, 0, ML_DATUM, 2);
        const int titleWidth = tft.textWidth(tr(e.zh, e.en));
        text(tr(e.zhSub, e.enSub), r.x + 12, r.y + 49, Font::Small, kDim, kCard, 0, ML_DATUM, 2);
        const int subWidth = tft.textWidth(tr(e.zhSub, e.enSub));
        // The icon sits top-right; long titles ("继电器") push it to the subtitle row, or drop it.
        const int iconLeft = r.w - 13 - 10;
        if (12 + titleWidth + 3 <= iconLeft) {
            homeIcon(i, r.x + r.w - 13, r.y + 18, e.color, kCard);
        } else if (12 + subWidth + 3 <= iconLeft) {
            homeIcon(i, r.x + r.w - 13, r.y + 48, e.color, kCard);
        }
    }
}

// The digit panel of the resistor page; digits and arrows are drawn on kCard.
constexpr int kDigitPanelY = 28;
constexpr int kDigitPanelH = 86;

void drawDigitArrows(int i, bool focused) {
    const int x = digitX(i);
    const std::uint16_t c = focused ? kAccent : kBorder;
    tft.fillTriangle(x + 6, 40, x + 26, 40, x + 16, 31, c);
    tft.fillTriangle(x + 6, 94, x + 26, 94, x + 16, 103, c);
}

void staticResistor() {
    panel(6, kDigitPanelY, 308, kDigitPanelH, 10, kCard);
    text("Ω", 288, 68, Font::Large, kDim, kCard, 0, MC_DATUM, 2);
}

void renderResistor() {
    const auto& st = app::state();
    std::uint32_t value = st.targetOhms;
    int digits[6];
    for (int i = 5; i >= 0; --i) {
        digits[i] = static_cast<int>(value % 10);
        value /= 10;
    }
    bool leading = true;
    for (int i = 0; i < 6; ++i) {
        if (digits[i] != 0 || i == 5) {
            leading = false;
        }
        const int x = digitX(i);
        bigNumber(i, x, 43, 34, String(digits[i]), leading ? kBorder : kFg, TL_DATUM, kCard);
        if (changed(10 + i, "", resistorField == i ? 1 : 0)) {
            drawDigitArrows(i, resistorField == i);
            tft.fillRect(x, 105, 32, 5, kCard);
            if (resistorField == i) {
                tft.fillSmoothRoundRect(x + 2, 105, 28, 4, 2, kAccent, kCard);
            }
        }
    }
    String detail = tr("继电器手动模式", "RAW relay mode");
    if (!app::rawMode()) {
        detail = String(tr("实际 ", "Actual ")) + String(st.estimatedOhms, 3) + " Ω";
    }
    label(20, 12, 121, 300, detail, Font::Large, kInfo);
    String mode = tr("点数字上半 +1 / 下半 -1，旋钮转动修改", "Tap top half +1 / bottom half -1");
    if (app::ntcActive()) {
        mode = String("NTC ") + ntcTypeName(app::settings().ntcPreset) + " @ " + String(app::ntcTemperature(), 1) + "°C";
    }
    label(21, 12, 152, 300, mode, Font::Small, kDim);
    label(22, 12, 172, 300, st.locked ? tr("已锁定（远程控制中）", "LOCKED (remote)") : "", Font::Small, kWarn);
    button(23, kOutputButton, st.outputEnabled ? tr("输出：开", "OUTPUT ON") : tr("输出：关", "OUTPUT OFF"),
        st.outputEnabled ? Style::On : Style::Muted, Font::Large, resistorField == 6);
}

const Rect kNtcType = {10, 30, 300, 34};
const Rect kNtcStep[4] = {{10, 140, 72, 32}, {86, 140, 72, 32}, {162, 140, 72, 32}, {238, 140, 72, 32}};
const double kNtcStepValue[4] = {-1.0, -0.1, 0.1, 1.0};
const Rect kNtcOutput = {10, 200, 300, 34};

void staticNtc() {
    panel(8, 86, 304, 50, 10, kCard);
    text("°C", 246, 100, Font::Large, kDim, kCard, 0, TL_DATUM, 2);
}

void renderNtc() {
    button(0, kNtcType, "<    " + ntcTypeName(app::settings().ntcPreset) + "    >", Style::Normal, Font::Large, ntcField == 0);
    label(1, 14, 70, 296, "R25 " + String(app::ntcR25(), 0) + " Ω    B " + String(app::ntcBeta(), 0), Font::Small, kDim);
    bigNumber(2, 238, 87, 224, String(ntcEditTemp, 1), kFg, TR_DATUM, kCard);
    const char* names[4] = {"-1", "-0.1", "+0.1", "+1"};
    for (int i = 0; i < 4; ++i) {
        const bool focused = (ntcField == 1 && (i == 0 || i == 3)) || (ntcField == 2 && (i == 1 || i == 2));
        button(3 + i, kNtcStep[i], names[i], Style::Normal, Font::Large, focused);
    }
    const double ideal = smart_resistance::ntcResistanceOhms(app::ntcR25(), app::ntcBeta(), ntcEditTemp);
    String line = "R " + String(ideal, 1) + " Ω";
    if (ideal > smart_resistance::kMaximumResistanceOhms) {
        line += tr("  超出范围", "  over range");
    } else if (app::ntcActive()) {
        line += app::sweepRunning() ? tr("  扫描中", "  sweeping") : tr("  已应用", "  applied");
    } else {
        line += tr("  未应用", "  not applied");
    }
    label(7, 14, 178, 296, line, Font::Small, kInfo);
    button(8, kNtcOutput, app::state().outputEnabled ? tr("输出：开", "OUTPUT ON") : tr("输出：关", "OUTPUT OFF"),
        app::state().outputEnabled ? Style::On : Style::Muted, Font::Large, ntcField == 3);
}

void applyNtcEdit() {
    if (app::state().locked) {
        return;
    }
    app::stopSweep();
    if (smart_resistance::ntcResistanceOhms(app::ntcR25(), app::ntcBeta(), ntcEditTemp)
        <= smart_resistance::kMaximumResistanceOhms) {
        app::setNtcTemperature(ntcEditTemp);
    }
}

void stepNtc(double delta) {
    ntcEditTemp = std::round((ntcEditTemp + delta) * 10.0) / 10.0;
    ntcEditTemp = std::min(smart_resistance::kNtcMaxTempC, std::max(smart_resistance::kNtcMinTempC, ntcEditTemp));
    applyNtcEdit();
}

void stepNtcType(int steps) {
    app::selectNtc(wrap(app::settings().ntcPreset + steps, app::ntcTypeCount()));
    applyNtcEdit();
}

const Rect kBleMode[2] = {{10, 98, 148, 36}, {162, 98, 148, 36}};
const Rect kBleToggle = {10, 144, 300, 38};

void setBleBridgeMode(bool bridge) {
    app::settings().bleBridge = bridge;
    comm::setBleBridge(bridge);
    app::saveSettings();
}

void setBleOn(bool on) {
    app::settings().bleEnabled = on;
    comm::setBleEnabled(on);
    app::saveSettings();
}

void renderBluetooth() {
    label(0, 14, 34, 296, comm::bleName(), Font::Large, kFg);
    String status;
    std::uint16_t color = kInfo;
    if (!comm::bleEnabled()) {
        status = tr("蓝牙已关闭", "Bluetooth off");
        color = kDim;
    } else if (comm::bleConnected()) {
        status = String(tr("已连接  ", "Connected  ")) + comm::blePeer();
        color = kGood;
    } else {
        status = tr("等待连接（广播中）", "Advertising, waiting");
    }
    label(1, 14, 68, 296, status, Font::Small, color);
    const bool bridge = comm::bleBridge();
    button(2, kBleMode[0], tr("指令模式", "Commands"), bridge ? Style::Normal : Style::On, Font::Small, bleField == 0);
    button(3, kBleMode[1], tr("串口透传", "UART bridge"), bridge ? Style::On : Style::Normal, Font::Small, bleField == 0);
    button(4, kBleToggle, comm::bleEnabled() ? tr("关闭蓝牙", "Turn Bluetooth off") : tr("打开蓝牙", "Turn Bluetooth on"),
        comm::bleEnabled() ? Style::Off : Style::On, Font::Large, bleField == 1);
    if (bridge) {
        label(5, 14, 192, 296, tr("手机收发的数据直通 J_DBG 串口", "Phone data goes straight to J_DBG"), Font::Small, kDim);
        label(6, 14, 214, 296, String(tr("波特率 ", "Baud ")) + String(app::settings().bridgeBaud)
            + tr("（在串口页修改）", " (set on Serial page)"), Font::Small, kDim);
    } else {
        label(5, 14, 192, 296, tr("手机用 nRF Toolbox 或 Serial Bluetooth", "Use nRF Toolbox / Serial Bluetooth"), Font::Small, kDim);
        label(6, 14, 214, 296, tr("Terminal 扫描连接，发 HELP 看指令", "Terminal, then send HELP"), Font::Small, kDim);
    }
}

const Rect kKnobMode[4] = {{10, 34, 72, 44}, {86, 34, 72, 44}, {162, 34, 72, 44}, {238, 34, 72, 44}};
const Rect kKnobStart = {10, 120, 300, 56};

void renderKnob() {
    const int mode = app::settings().knobMode;
    for (int i = 0; i < 4; ++i) {
        button(i, kKnobMode[i], knobModeLabel(i), i == mode ? Style::Selected : Style::Normal, Font::Small, false);
    }
    const char* hint = "";
    switch (mode) {
        case 0: hint = tr("转动 = 音量，按下 = 静音", "Turn = volume, press = mute"); break;
        case 1: hint = tr("转动 = 滚轮，按下 = 中键", "Turn = wheel, press = middle click"); break;
        case 2: hint = tr("转动 = 上/下一首，按下 = 播放", "Turn = next/prev, press = play"); break;
        case 3: hint = tr("转动 = 上下方向键，按下 = 回车", "Turn = up/down, press = Enter"); break;
        default: break;
    }
    label(4, 14, 88, 296, hint, Font::Small, kInfo);
    button(5, kKnobStart, knobArmed ? tr("停止", "Stop") : tr("开始", "Start"), knobArmed ? Style::Off : Style::On,
        Font::Large, false);
    label(6, 14, 190, 296, knobArmed ? tr("旋钮的转动和按键正在发给电脑", "Knob events go to the PC")
                                     : tr("选好模式后点开始，或按一下旋钮", "Pick a mode, then Start or press"), Font::Small, kDim);
    label(7, 14, 212, 296, tr("长按旋钮或点左上角返回", "Hold the knob or tap Back"), Font::Small, kDim);
}

const Rect kSerialBaud = {4, 30, 124, 24};
const Rect kSerialPause = {132, 30, 90, 24};
const Rect kSerialClear = {226, 30, 90, 24};
constexpr int kSerialRows = 22;

void renderSerial() {
    button(0, kSerialBaud, String(app::settings().bridgeBaud) + " 8N1", Style::Normal, Font::Small, false);
    button(1, kSerialPause, comm::bridgePaused() ? tr("继续", "Resume") : tr("暂停", "Pause"),
        comm::bridgePaused() ? Style::Selected : Style::Normal, Font::Small, false);
    button(2, kSerialClear, tr("清空", "Clear"), Style::Normal, Font::Small, false);
    const std::uint32_t revision = comm::bridgeRevision();
    if (revision == bridgeDrawnRev) {
        return;
    }
    bridgeDrawnRev = revision;
    const int first = comm::kBridgeLineCount - kSerialRows;
    for (int row = 0; row < kSerialRows; ++row) {
        text(comm::bridgeLine(first + row), 1, 58 + row * 8, Font::Builtin, kGood, kBg, kWidth - 2, TL_DATUM, 1);
    }
}

const Rect kLogInterval = {150, 30, 80, 28};
const Rect kLogClear = {234, 30, 82, 28};

void renderTempLog() {
    const int count = app::tempLogCount();
    String now = tr("无 TMP117", "no TMP117");
    if (app::tempValid()) {
        now = String(app::boardTempC(), 2) + "°C";
    }
    label(0, 6, 32, 140, now, Font::Large, kFg);
    button(1, kLogInterval, String(tr("间隔 ", "Every ")) + String(app::settings().logIntervalS) + "s", Style::Normal,
        Font::Small, false);
    button(2, kLogClear, tr("清空", "Clear"), Style::Normal, Font::Small, false);
    if (count == tempDrawnCount && count < app::kTempLogSize) {
        return;
    }
    tempDrawnCount = count;

    const int x0 = 44;
    const int y0 = 66;
    const int width = app::kTempLogSize - 30;
    const int height = 162;
    tft.fillRect(0, y0 - 2, kWidth, height + 12, kBg);
    tft.drawRect(x0 - 1, y0 - 1, width + 2, height + 2, kBorder);
    if (count < 2) {
        text(tr("数据采集中…", "Collecting…"), x0 + width / 2, y0 + height / 2, Font::Small, kDim, kBg, 0, MC_DATUM, 2);
        return;
    }
    float low = 1e9f;
    float high = -1e9f;
    for (int i = 0; i < count; ++i) {
        const float value = app::tempLogAt(i);
        low = std::min(low, value);
        high = std::max(high, value);
    }
    if (high - low < 0.5f) {
        const float mid = (high + low) / 2;
        low = mid - 0.25f;
        high = mid + 0.25f;
    }
    text(String(high, 2), 0, y0, Font::Builtin, kDim, kBg, 0, TL_DATUM, 1);
    text(String(low, 2), 0, y0 + height - 8, Font::Builtin, kDim, kBg, 0, TL_DATUM, 1);
    int previousX = 0;
    int previousY = 0;
    for (int i = 0; i < count; ++i) {
        const int x = x0 + (count <= width ? i : static_cast<int>(static_cast<long>(i) * (width - 1) / (count - 1)));
        const int y = y0 + height - 1 - static_cast<int>((app::tempLogAt(i) - low) / (high - low) * (height - 1));
        if (i > 0) {
            tft.drawLine(previousX, previousY, x, y, kInfo);
        }
        previousX = x;
        previousY = y;
    }
}

// ------------------------------------------------------------ message cards
constexpr int kMsgCardX = 8;
constexpr int kMsgCardW = 304;
constexpr int kMsgListY = 30;
constexpr int kMsgCardStep = 60;     // card height is bitmap height (<= 50) + 8
constexpr int kInfoCardY = 182;

void resetSlotRange(int first, int last) {
    for (int i = first; i <= last; ++i) {
        slotText[i] = "\x01";
        slotKey[i] = 0xFFFFFFFF;
    }
}

std::uint16_t appColor(msg::App app) {
    switch (app) {
        case msg::App::Feishu: return rgb(0x3370FF);
        case msg::App::WeChat: return rgb(0x07C160);
        default: return kDim;
    }
}

// Card = rounded panel + app colour strip + the host-rendered 2-bit text bitmap.
// Pixels are drawn as horizontal runs; background (level 0) is skipped.
void drawMessageCard(int x, int y, const msg::Message& m) {
    const int h = m.height + 8;
    panel(x, y, kMsgCardW, h, 9, kCard);
    tft.fillSmoothRoundRect(x + 4, y + 7, 4, std::max(4, h - 14), 2, appColor(m.app), kCard);
    const std::uint16_t palette[4] = {kCard, tft.alphaBlend(85, kFg, kCard), tft.alphaBlend(170, kFg, kCard), kFg};
    const int stride = (m.width + 3) / 4;
    const int bx = x + 12;
    const int by = y + 4;
    tft.startWrite();
    for (int row = 0; row < m.height; ++row) {
        const std::uint8_t* line = m.pixels + row * stride;
        int col = 0;
        while (col < m.width) {
            const int level = (line[col >> 2] >> (6 - 2 * (col & 3))) & 3;
            int end = col + 1;
            while (end < m.width && ((line[end >> 2] >> (6 - 2 * (end & 3))) & 3) == level) {
                ++end;
            }
            if (level != 0) {
                tft.drawFastHLine(bx + col, by + row, end - col, palette[level]);
            }
            col = end;
        }
    }
    tft.endWrite();
}

void renderInfo() {
    comm::requestWeather();
    if (comm::timeValid()) {
        const time_t now = time(nullptr);
        struct tm local;
        localtime_r(&now, &local);
        char clock[12];
        char date[16];
        strftime(clock, sizeof(clock), "%H:%M:%S", &local);
        strftime(date, sizeof(date), "%Y-%m-%d", &local);
        static const char* const zhWeek[] = {"周日", "周一", "周二", "周三", "周四", "周五", "周六"};
        static const char* const enWeek[] = {"Sun", "Mon", "Tue", "Wed", "Thu", "Fri", "Sat"};
        bigNumber(0, 30, 36, 270, clock, kFg, TL_DATUM);
        label(1, 30, 94, 280, String(date) + "  " + tr(zhWeek[local.tm_wday], enWeek[local.tm_wday]), Font::Large, kInfo);
    } else {
        bigNumber(0, 30, 36, 270, "--:--:--", kDim, TL_DATUM);
        label(1, 30, 98, 280, comm::wifiConnected() ? tr("等待网络对时", "Waiting for NTP")
                                                    : tr("未连路由器：用 WIFI 指令配置", "No Wi-Fi: use the WIFI command"),
            Font::Small, kDim);
    }
    String board = String(tr("板温 ", "Board ")) + "-";
    if (app::tempValid()) {
        board = String(tr("板温 ", "Board ")) + String(app::boardTempC(), 2) + "°C";
    }
    label(2, 30, 128, 280, board, Font::Large, kFg);
    label(3, 30, 162, 280, comm::weatherLine(), Font::Small, kWarn);
    // With messages stored, the newest card replaces the IP / resistance lines (tap it to open the list).
    const bool showCard = msg::count() > 0;
    if (changed(6, "", showCard ? msg::revision() : 0U)) {
        tft.fillRect(0, kInfoCardY, kWidth, kHeight - kInfoCardY, kBg);
        resetSlotRange(4, 5);
        msg::Message m;
        if (showCard && msg::get(0, m)) {
            drawMessageCard(kMsgCardX, kInfoCardY, m);
        }
    }
    if (!showCard) {
        label(4, 30, 186, 280, "IP " + comm::ipAddress(), Font::Small, kDim);
        label(5, 30, 208, 280, String(tr("电阻 ", "R ")) + String(app::state().targetOhms) + " Ω  "
            + (app::state().outputEnabled ? tr("输出开", "ON") : tr("输出关", "OFF")), Font::Small, kDim);
    }
}

// ------------------------------------------------------------ messages page
constexpr int kMsgVisible = 3;

int msgMaxScroll() {
    return std::max(0, msg::count() - kMsgVisible);
}

void renderMessages() {
    const int total = msg::count();
    msgScroll = std::min(msgScroll, msgMaxScroll());
    if (!changed(0, "", msg::revision() * 64U + static_cast<std::uint32_t>(msgScroll))) {
        return;
    }
    tft.fillRect(0, kBar + 1, kWidth, kHeight - kBar - 1, kBg);
    resetSlotRange(1, 2);
    if (total == 0) {
        label(1, kWidth / 2, 104, 300, tr("暂无消息", "No messages"), Font::Large, kDim, TC_DATUM);
        label(2, kWidth / 2, 140, 300, tr("在电脑上位机里打开\"消息转发\"", "Turn on forwarding in the PC host"),
            Font::Small, kDim, TC_DATUM);
        return;
    }
    for (int i = 0; i < kMsgVisible; ++i) {
        msg::Message m;
        if (msg::get(msgScroll + i, m)) {
            drawMessageCard(kMsgCardX, kMsgListY + i * kMsgCardStep, m);
        }
    }
    const int last = std::min(total, msgScroll + kMsgVisible);
    label(1, kWidth / 2, 216, 300, String(msgScroll + 1) + "-" + String(last) + " / " + String(total)
        + tr("   旋钮或点上下翻页", "   turn / tap to scroll"), Font::Small, kDim, TC_DATUM);
}

void scrollMessages(int steps) {
    msgScroll = std::max(0, std::min(msgMaxScroll(), msgScroll + steps));
}

const int kRelayRowY[4] = {32, 66, 100, 134};
const Rect kRelayStart = {10, 170, 300, 34};

Rect relayMinus(int row) {
    return Rect{216, static_cast<std::int16_t>(kRelayRowY[row]), 46, 30};
}

Rect relayPlus(int row) {
    return Rect{268, static_cast<std::int16_t>(kRelayRowY[row]), 46, 30};
}

void renderRelayTest() {
    const bool running = app::relayCycleRunning();
    const char* names[4] = {tr("继电器", "Relay"), tr("吸合", "On"), tr("释放", "Off"), tr("次数", "Count")};
    String values[4] = {
        String(relayIndex) + "  " + relayName(relayIndex),
        String(relayOnMs) + " ms",
        String(relayOffMs) + " ms",
        relayCount == 0 ? String(tr("不限", "endless")) : String(relayCount),
    };
    for (int row = 0; row < 4; ++row) {
        label(row, 10, kRelayRowY[row] + 7, 70, names[row], Font::Small, kDim);
        label(4 + row, 82, kRelayRowY[row] + 7, 130, values[row], Font::Small, relayField == row ? kAccent : kFg);
        const Style style = running ? Style::Disabled : Style::Normal;
        button(8 + row, relayMinus(row), "-", style, Font::Large, false);
        button(12 + row, relayPlus(row), "+", style, Font::Large, false);
    }
    button(16, kRelayStart, running ? tr("停止", "Stop") : tr("开始", "Start"), running ? Style::Off : Style::On,
        Font::Large, relayField == 4);
    label(17, 14, 212, 296, String(tr("已完成 ", "Done ")) + String(app::relayCycleCount())
        + tr(" 次", "") + (running ? tr("  运行中", "  running") : ""), Font::Small, running ? kGood : kFg);
}

void adjustRelayRow(int row, int steps) {
    if (app::relayCycleRunning()) {
        return;
    }
    if (row == 0) {
        relayIndex = wrap(relayIndex + steps, app::kRelayIndexCount);
    } else if (row == 1) {
        relayOnMs = stepClamped(relayOnMs, steps, 50, 50, 10000);
    } else if (row == 2) {
        relayOffMs = stepClamped(relayOffMs, steps, 50, 50, 10000);
    } else {
        relayCount = stepClamped(relayCount, steps, 10, 0, 100000);
    }
}

void toggleRelayCycle() {
    if (app::relayCycleRunning()) {
        app::stopRelayCycle();
    } else {
        app::startRelayCycle(relayIndex, relayOnMs, relayOffMs, relayCount);
    }
}

const Rect kLightMinus = {150, 114, 50, 30};
const Rect kLightPlus = {262, 114, 50, 30};
const Rect kFlipButton = {10, 152, 96, 32};
const Rect kLangButton = {112, 152, 96, 32};
const Rect kCalButton = {214, 152, 96, 32};
const Rect kTouchOffButton = {214, 194, 96, 32};

void renderAbout() {
    const app::Settings& config = app::settings();
    label(0, 10, 30, 300, String(tr("固件 ", "Firmware ")) + app::kFirmwareVersion + "   " + comm::bleName(), Font::Small, kInfo);
    String wifi;
    if (comm::wifiConnected()) {
        wifi = "Wi-Fi " + config.wifiSsid + "  " + comm::ipAddress();
    } else if (comm::accessPointActive()) {
        wifi = String(tr("热点 ", "AP ")) + comm::accessPointName() + tr("  密码 12345678", "  pass 12345678");
    } else {
        wifi = String(tr("正在连接 ", "Connecting ")) + config.wifiSsid;
    }
    label(1, 10, 50, 300, wifi, Font::Small, kFg);
    label(2, 10, 70, 300, String(tr("网页 http://", "Web http://")) + comm::ipAddress() + "  TCP 5025", Font::Small, kFg);
    const String mqtt = comm::mqttStatus();
    const char* remote = mqtt == "off" ? tr("未配置", "not set")
        : (mqtt == "connected" ? tr("已连接", "online") : tr("未连接", "offline"));
    label(3, 10, 90, 300, String(tr("蓝牙 ", "BLE ")) + (comm::bleEnabled() ? (comm::bleConnected() ? tr("已连接", "connected")
        : tr("广播中", "advertising")) : tr("已关闭", "off")) + tr("    远程 ", "    Remote ") + remote,
        Font::Small, mqtt == "connected" ? kGood : kFg);

    label(4, 10, 121, 130, tr("背光亮度", "Backlight"), Font::Small, settingsField == 0 ? kAccent : kFg);
    button(5, kLightMinus, "-", Style::Normal, Font::Large, false);
    label(6, 231, 121, 56, String(config.backlight) + "%", Font::Small, kFg, TC_DATUM);
    button(7, kLightPlus, "+", Style::Normal, Font::Large, false);
    button(8, kFlipButton, tr("屏幕翻转", "Flip"), Style::Normal, Font::Small, settingsField == 1);
    button(9, kLangButton, config.language == 1 ? "中文" : "English", Style::Normal, Font::Small, settingsField == 2);
    button(10, kCalButton, tr("触摸校准", "Calibrate"), Style::Accent, Font::Small, settingsField == 3);
    label(11, 10, 202, 200, config.touchValid ? tr("触摸：已校准", "Touch: calibrated") : tr("触摸：未校准", "Touch: not set"),
        Font::Small, config.touchValid ? kGood : kDim);
    button(12, kTouchOffButton, tr("关闭触摸", "Touch off"), config.touchValid ? Style::Off : Style::Disabled, Font::Small, false);
}

void setBacklightSteps(int steps) {
    app::Settings& config = app::settings();
    config.backlight = static_cast<std::uint8_t>(stepClamped(config.backlight, steps, 10, 10, 100));
    applyDisplaySettings();
}

void enterPage(Page page);

void flipScreen() {
    app::Settings& config = app::settings();
    config.rotation = config.rotation == 1 ? 3 : 1;
    app::saveSettings();
    applyDisplaySettings();
    enterPage(currentPage);
}

void toggleLanguage() {
    app::Settings& config = app::settings();
    config.language = config.language == 1 ? 0 : 1;
    app::saveSettings();
    enterPage(currentPage);
}

// ------------------------------------------------------------ touch calibration page
void drawCalibrationTarget() {
    tft.fillScreen(kBg);
    const int x = kCalX[calStep];
    const int y = kCalY[calStep];
    tft.drawFastHLine(x - 15, y, 31, kFg);
    tft.drawFastVLine(x, y - 15, 31, kFg);
    tft.drawCircle(x, y, 7, kBad);
    text(tr("触摸校准", "Touch calibration"), kWidth / 2, 96, Font::Large, kFg, kBg, 0, MC_DATUM, 2);
    text(String(tr("请用笔尖点十字中心  ", "Tap the centre of the cross  ")) + String(calStep + 1) + "/4",
        kWidth / 2, 130, Font::Small, kInfo, kBg, 0, MC_DATUM, 2);
    text(tr("按一下旋钮跳过", "Press the knob to skip"), kWidth / 2, 154, Font::Small, kDim, kBg, 0, MC_DATUM, 2);
}

// Least-squares affine fit: screen = a*rx + b*ry + c (one 3x3 solve per axis).
bool solve3(double m[3][3], const double rhs[3], double out[3]) {
    double a[3][4];
    for (int r = 0; r < 3; ++r) {
        for (int c = 0; c < 3; ++c) {
            a[r][c] = m[r][c];
        }
        a[r][3] = rhs[r];
    }
    for (int col = 0; col < 3; ++col) {
        int pivot = col;
        for (int r = col + 1; r < 3; ++r) {
            if (std::fabs(a[r][col]) > std::fabs(a[pivot][col])) {
                pivot = r;
            }
        }
        if (std::fabs(a[pivot][col]) < 1e-9) {
            return false;
        }
        for (int c = 0; c < 4; ++c) {
            std::swap(a[col][c], a[pivot][c]);
        }
        for (int r = 0; r < 3; ++r) {
            if (r == col) {
                continue;
            }
            const double factor = a[r][col] / a[col][col];
            for (int c = col; c < 4; ++c) {
                a[r][c] -= factor * a[col][c];
            }
        }
    }
    for (int r = 0; r < 3; ++r) {
        out[r] = a[r][3] / a[r][r];
    }
    return true;
}

bool finishCalibration() {
    double m[3][3] = {{0, 0, 0}, {0, 0, 0}, {0, 0, 0}};
    double bx[3] = {0, 0, 0};
    double by[3] = {0, 0, 0};
    for (int i = 0; i < 4; ++i) {
        const double v[3] = {calRawX[i], calRawY[i], 1.0};
        for (int r = 0; r < 3; ++r) {
            for (int c = 0; c < 3; ++c) {
                m[r][c] += v[r] * v[c];
            }
            bx[r] += v[r] * kCalX[i];
            by[r] += v[r] * kCalY[i];
        }
    }
    double mx[3][3];
    double my[3][3];
    for (int r = 0; r < 3; ++r) {
        for (int c = 0; c < 3; ++c) {
            mx[r][c] = m[r][c];
            my[r][c] = m[r][c];
        }
    }
    double cx[3];
    double cy[3];
    if (!solve3(mx, bx, cx) || !solve3(my, by, cy)) {
        return false;
    }
    for (int i = 0; i < 4; ++i) {
        const double ex = cx[0] * calRawX[i] + cx[1] * calRawY[i] + cx[2] - kCalX[i];
        const double ey = cy[0] * calRawX[i] + cy[1] * calRawY[i] + cy[2] - kCalY[i];
        if (std::fabs(ex) > 20 || std::fabs(ey) > 20) {
            return false;
        }
    }
    app::Settings& config = app::settings();
    for (int i = 0; i < 3; ++i) {
        config.touchCal[i] = static_cast<float>(cx[i]);
        config.touchCal[3 + i] = static_cast<float>(cy[i]);
    }
    config.touchRotation = config.rotation;
    config.touchValid = true;
    config.touchSkipped = false;
    app::saveSettings();
    return true;
}

void restartCalibration() {
    calStep = 0;
    calSamples = 0;
    calSumX = 0;
    calSumY = 0;
    calWaitRelease = false;
    calReleaseCount = 0;
    drawCalibrationTarget();
}

void serviceCalibration(std::uint32_t now) {
    if (now - lastTouchPollMs < kTouchPollMs) {
        return;
    }
    lastTouchPollMs = now;
    std::uint16_t rx = 0;
    std::uint16_t ry = 0;
    std::uint16_t rz = 0;
    const bool down = readTouchRaw(rx, ry, rz);
    if (calWaitRelease) {
        calReleaseCount = down ? 0 : calReleaseCount + 1;
        if (calReleaseCount >= 3) {
            calWaitRelease = false;
            if (calStep < 4) {
                drawCalibrationTarget();
            }
        }
        return;
    }
    if (!down) {
        calSamples = 0;
        calSumX = 0;
        calSumY = 0;
        return;
    }
    calSumX += rx;
    calSumY += ry;
    if (++calSamples < 6) {
        return;
    }
    calRawX[calStep] = static_cast<float>(calSumX) / calSamples;
    calRawY[calStep] = static_cast<float>(calSumY) / calSamples;
    calSamples = 0;
    calSumX = 0;
    calSumY = 0;
    calWaitRelease = true;
    calReleaseCount = 0;
    tft.fillCircle(kCalX[calStep], kCalY[calStep], 7, kGood);
    if (++calStep < 4) {
        return;
    }
    tft.fillScreen(kBg);
    if (finishCalibration()) {
        text(tr("校准完成", "Calibration done"), kWidth / 2, kHeight / 2, Font::Large, kGood, kBg, 0, MC_DATUM, 2);
        delay(800);
        requestedPage = returnPage;
        pageChangePending = true;
    } else {
        text(tr("校准失败，请重新点击", "Failed, please try again"), kWidth / 2, kHeight / 2, Font::Large, kBad, kBg, 0,
            MC_DATUM, 2);
        delay(1000);
        restartCalibration();
    }
}

// ------------------------------------------------------------ page switching / dispatch
void clearContent() {
    useFont(Font::Builtin);
    tft.fillScreen(kBg);
    resetSlots();
    if (currentPage == Page::TouchCal) {
        return;
    }
    tft.fillRect(0, 0, kWidth, kBar, kBarColor);
    tft.drawFastHLine(0, kBar, kWidth, kBorder);
    switch (currentPage) {
        case Page::Resistor: staticResistor(); break;
        case Page::Ntc: staticNtc(); break;
        default: break;
    }
}

void enterPage(Page page) {
    // Leaving a page: stop what only makes sense while it is shown.
    if (currentPage == Page::RelayTest && page != Page::RelayTest) {
        app::leaveRawMode();
    }
    if (currentPage == Page::Serial && page != Page::Serial) {
        comm::setBridgePaused(false);
    }
    if (currentPage != Page::Menu && page == Page::Menu) {
        app::saveSettings();
    }

    currentPage = page;
    knobArmed = false;
    bridgeDrawnRev = 0xFFFFFFFF;
    tempDrawnCount = -1;
    touchHeld = true;          // ignore the finger that is still on the glass after a page change
    touchRepeat = false;
    if (page == Page::Ntc) {
        ntcEditTemp = app::ntcTemperature();
    }
    if (page == Page::Messages) {
        msgScroll = 0;
        msg::markAllRead();
    }
    if (page == Page::Menu) {
        for (int i = 0; i < kHomeCount; ++i) {
            if (kHome[i].page == returnPage) {
                homeIndex = i;
            }
        }
    }
    clearContent();
    if (page == Page::TouchCal) {
        restartCalibration();
    }
    dirty = true;
}

void renderPage() {
    if (currentPage == Page::TouchCal) {
        return;
    }
    drawStatusBar();
    switch (currentPage) {
        case Page::Menu: renderHome(); break;
        case Page::Resistor: renderResistor(); break;
        case Page::Ntc: renderNtc(); break;
        case Page::Bluetooth: renderBluetooth(); break;
        case Page::Knob: renderKnob(); break;
        case Page::Serial: renderSerial(); break;
        case Page::TempLog: renderTempLog(); break;
        case Page::Info: renderInfo(); break;
        case Page::RelayTest: renderRelayTest(); break;
        case Page::About: renderAbout(); break;
        case Page::Messages: renderMessages(); break;
        default: break;
    }
}

enum class Tap : std::uint8_t { None, Done, Repeat };

Tap onTouch(int x, int y) {
    if (currentPage != Page::Menu && y < kBar && x < 80) {
        goHome();
        return Tap::Done;
    }
    // "新消息 N" in the status bar opens the message list.
    if (y < kBar && x >= 166 && x < 266 && msg::count() > 0 && currentPage != Page::Messages) {
        returnPage = currentPage;
        setPage(Page::Messages);
        return Tap::Done;
    }
    app::Settings& config = app::settings();
    switch (currentPage) {
        case Page::Info:
            if (y >= kInfoCardY && msg::count() > 0) {
                setPage(Page::Messages);
                return Tap::Done;
            }
            break;

        case Page::Messages:
            if (y >= kBar) {
                scrollMessages(y < kHeight / 2 ? -1 : 1);
                return Tap::Repeat;
            }
            break;

        case Page::Menu:
            for (int i = 0; i < kHomeCount; ++i) {
                if (homeTile(i).contains(x, y)) {
                    homeIndex = i;
                    setPage(kHome[i].page);
                    return Tap::Done;
                }
            }
            break;

        case Page::Resistor:
            for (int i = 0; i < 6; ++i) {
                const int dx = digitX(i);
                if (x >= dx - 4 && x < dx + 36 && y >= 28 && y < 108) {
                    resistorField = i;
                    if (!app::state().locked) {
                        app::adjustDigit(static_cast<std::uint8_t>(5 - i), y < 67 ? 1 : -1);
                    }
                    return Tap::Repeat;
                }
            }
            if (kOutputButton.contains(x, y)) {
                resistorField = 6;
                app::setOutput(!app::state().outputEnabled);
                return Tap::Done;
            }
            break;

        case Page::Ntc:
            if (kNtcType.contains(x, y)) {
                ntcField = 0;
                stepNtcType(x < kNtcType.x + kNtcType.w / 2 ? -1 : 1);
                return Tap::Done;
            }
            for (int i = 0; i < 4; ++i) {
                if (kNtcStep[i].contains(x, y)) {
                    ntcField = (i == 0 || i == 3) ? 1 : 2;
                    stepNtc(kNtcStepValue[i]);
                    return Tap::Repeat;
                }
            }
            if (kNtcOutput.contains(x, y)) {
                ntcField = 3;
                const bool on = !app::state().outputEnabled;
                if (on && !app::ntcActive()) {
                    app::setNtcTemperature(ntcEditTemp);
                }
                app::setOutput(on);
                return Tap::Done;
            }
            break;

        case Page::Bluetooth:
            for (int i = 0; i < 2; ++i) {
                if (kBleMode[i].contains(x, y)) {
                    bleField = 0;
                    setBleBridgeMode(i == 1);
                    return Tap::Done;
                }
            }
            if (kBleToggle.contains(x, y)) {
                bleField = 1;
                setBleOn(!comm::bleEnabled());
                return Tap::Done;
            }
            break;

        case Page::Knob:
            for (int i = 0; i < 4; ++i) {
                if (kKnobMode[i].contains(x, y)) {
                    config.knobMode = static_cast<std::uint8_t>(i);
                    knobArmed = false;
                    return Tap::Done;
                }
            }
            if (kKnobStart.contains(x, y)) {
                knobArmed = !knobArmed;
                return Tap::Done;
            }
            break;

        case Page::Serial:
            if (kSerialBaud.contains(x, y)) {
                int index = 0;
                for (int i = 0; i < kBaudCount; ++i) {
                    if (kBaudRates[i] == config.bridgeBaud) {
                        index = i;
                    }
                }
                config.bridgeBaud = kBaudRates[wrap(index + 1, kBaudCount)];
                comm::setBridgeBaud(config.bridgeBaud);
                return Tap::Done;
            }
            if (kSerialPause.contains(x, y)) {
                comm::setBridgePaused(!comm::bridgePaused());
                return Tap::Done;
            }
            if (kSerialClear.contains(x, y)) {
                comm::clearBridgeLog();
                return Tap::Done;
            }
            break;

        case Page::TempLog:
            if (kLogInterval.contains(x, y)) {
                int index = 0;
                for (int i = 0; i < kLogIntervalCount; ++i) {
                    if (kLogIntervals[i] == config.logIntervalS) {
                        index = i;
                    }
                }
                config.logIntervalS = kLogIntervals[wrap(index + 1, kLogIntervalCount)];
                return Tap::Done;
            }
            if (kLogClear.contains(x, y)) {
                app::clearTempLog();
                return Tap::Done;
            }
            break;

        case Page::RelayTest:
            for (int row = 0; row < 4; ++row) {
                if (relayMinus(row).contains(x, y) || relayPlus(row).contains(x, y)) {
                    relayField = row;
                    adjustRelayRow(row, relayPlus(row).contains(x, y) ? 1 : -1);
                    return Tap::Repeat;
                }
            }
            if (kRelayStart.contains(x, y)) {
                relayField = 4;
                toggleRelayCycle();
                return Tap::Done;
            }
            break;

        case Page::About:
            if (kLightMinus.contains(x, y) || kLightPlus.contains(x, y)) {
                settingsField = 0;
                setBacklightSteps(kLightPlus.contains(x, y) ? 1 : -1);
                return Tap::Repeat;
            }
            if (kFlipButton.contains(x, y)) {
                settingsField = 1;
                flipScreen();
                return Tap::Done;
            }
            if (kLangButton.contains(x, y)) {
                settingsField = 2;
                toggleLanguage();
                return Tap::Done;
            }
            if (kCalButton.contains(x, y)) {
                settingsField = 3;
                startTouchCalibration();
                return Tap::Done;
            }
            if (kTouchOffButton.contains(x, y) && config.touchValid) {
                config.touchValid = false;
                config.touchSkipped = true;
                app::saveSettings();
                return Tap::Done;
            }
            break;

        default:
            break;
    }
    return Tap::None;
}

void pollTouch(std::uint32_t now) {
    if (now - lastTouchPollMs < kTouchPollMs) {
        return;
    }
    lastTouchPollMs = now;
    if (!app::settings().touchValid) {
        return;
    }
    std::uint16_t rx = 0;
    std::uint16_t ry = 0;
    std::uint16_t rz = 0;
    if (!readTouchRaw(rx, ry, rz)) {
        touchDownCount = 0;
        touchHeld = false;
        return;
    }
    if (++touchDownCount < 2) {
        return;   // two consecutive samples before a tap counts
    }
    int x = 0;
    int y = 0;
    mapTouch(rx, ry, x, y);
    if (!touchHeld) {
        touchHeld = true;
        tapX = x;
        tapY = y;
        touchRepeat = onTouch(x, y) == Tap::Repeat;
        nextRepeatMs = now + 450;
        dirty = true;
    } else if (touchRepeat && static_cast<std::int32_t>(now - nextRepeatMs) >= 0) {
        nextRepeatMs = now + 110;
        onTouch(tapX, tapY);
        dirty = true;
    }
}

void onRotate(int steps) {
    app::Settings& config = app::settings();
    switch (currentPage) {
        case Page::Menu:
            homeIndex = wrap(homeIndex + steps, kHomeCount);
            break;

        case Page::Resistor:
            if (resistorField == 6) {
                app::setOutput(steps > 0);
            } else if (!app::state().locked) {
                app::adjustDigit(static_cast<std::uint8_t>(5 - resistorField), steps);
            }
            break;

        case Page::Ntc:
            if (ntcField == 3) {
                if (steps > 0 && !app::ntcActive()) {
                    app::setNtcTemperature(ntcEditTemp);
                }
                app::setOutput(steps > 0);
            } else if (ntcField == 0) {
                stepNtcType(steps);
            } else {
                stepNtc(steps * (ntcField == 1 ? 1.0 : 0.1));
            }
            break;

        case Page::Bluetooth:
            if (bleField == 0) {
                setBleBridgeMode(!comm::bleBridge());
            } else {
                setBleOn(steps > 0);
            }
            break;

        case Page::Knob:
            if (knobArmed) {
                comm::knobRotate(static_cast<comm::KnobMode>(config.knobMode), steps);
            } else {
                config.knobMode = static_cast<std::uint8_t>(
                    wrap(config.knobMode + steps, static_cast<int>(comm::KnobMode::Count)));
            }
            break;

        case Page::Serial: {
            int index = 0;
            for (int i = 0; i < kBaudCount; ++i) {
                if (kBaudRates[i] == config.bridgeBaud) {
                    index = i;
                }
            }
            config.bridgeBaud = kBaudRates[wrap(index + steps, kBaudCount)];
            comm::setBridgeBaud(config.bridgeBaud);
            break;
        }

        case Page::TempLog: {
            int index = 0;
            for (int i = 0; i < kLogIntervalCount; ++i) {
                if (kLogIntervals[i] == config.logIntervalS) {
                    index = i;
                }
            }
            config.logIntervalS = kLogIntervals[wrap(index + steps, kLogIntervalCount)];
            break;
        }

        case Page::RelayTest:
            if (relayField == 4) {
                if (steps > 0 && !app::relayCycleRunning()) {
                    app::startRelayCycle(relayIndex, relayOnMs, relayOffMs, relayCount);
                } else if (steps < 0) {
                    app::stopRelayCycle();
                }
            } else {
                adjustRelayRow(relayField, steps);
            }
            break;

        case Page::Messages:
            scrollMessages(steps);
            break;

        case Page::About:
            if (settingsField == 0) {
                setBacklightSteps(steps);
            } else if (settingsField == 1) {
                flipScreen();
            } else if (settingsField == 2) {
                toggleLanguage();
            } else if (steps > 0) {
                startTouchCalibration();
            }
            break;

        default:
            break;
    }
}

void onShortPress() {
    app::Settings& config = app::settings();
    switch (currentPage) {
        case Page::Menu:
            setPage(kHome[homeIndex].page);
            break;
        case Page::Resistor:
            resistorField = wrap(resistorField + 1, 7);
            break;
        case Page::Ntc:
            ntcField = wrap(ntcField + 1, 4);
            break;
        case Page::Bluetooth:
            bleField = wrap(bleField + 1, 2);
            break;
        case Page::Knob:
            if (knobArmed) {
                comm::knobClick(static_cast<comm::KnobMode>(config.knobMode));
            } else {
                knobArmed = true;
            }
            break;
        case Page::Serial:
            comm::setBridgePaused(!comm::bridgePaused());
            break;
        case Page::TempLog:
            app::clearTempLog();
            break;
        case Page::RelayTest:
            relayField = wrap(relayField + 1, 5);
            break;
        case Page::About:
            settingsField = wrap(settingsField + 1, 4);
            break;
        case Page::Messages:
            msgScroll = 0;      // back to the newest
            break;
        case Page::TouchCal:
            config.touchSkipped = true;
            app::saveSettings();
            requestedPage = returnPage;
            pageChangePending = true;
            break;
        default:
            break;
    }
}

}  // namespace

void begin() {
    pinMode(board::kEncoderA, INPUT_PULLUP);
    pinMode(board::kEncoderB, INPUT_PULLUP);
    pinMode(board::kEncoderSwitch, INPUT_PULLUP);
    pinMode(board::kTouchIrq, INPUT_PULLUP);
    encoderState = static_cast<std::uint8_t>(
        (digitalRead(board::kEncoderA) << 1) | digitalRead(board::kEncoderB));
    attachInterrupt(digitalPinToInterrupt(board::kEncoderA), onEncoderEdge, CHANGE);
    attachInterrupt(digitalPinToInterrupt(board::kEncoderB), onEncoderEdge, CHANGE);

    ledcSetup(kBacklightChannel, 5000, 8);
    ledcAttachPin(board::kTftBacklight, kBacklightChannel);
    ledcWrite(kBacklightChannel, 0);

    tft.init();
    resetSlots();
    applyDisplaySettings();
    tft.fillScreen(kBg);
}

void applyDisplaySettings() {
    const app::Settings& config = app::settings();
    tft.setRotation(config.rotation == 3 ? 3 : 1);
    ledcWrite(kBacklightChannel, static_cast<std::uint32_t>(config.backlight) * 255 / 100);
    resetSlots();
    dirty = true;
}

void setPage(Page page) {
    if (page >= Page::Count) {
        return;
    }
    if (page == Page::TouchCal) {
        startTouchCalibration();
        return;
    }
    requestedPage = page;
    pageChangePending = true;
}

Page page() {
    return currentPage;
}

void startTouchCalibration() {
    if (currentPage != Page::TouchCal) {
        returnPage = currentPage == Page::Menu ? Page::About : currentPage;
    }
    requestedPage = Page::TouchCal;
    pageChangePending = true;
}

bool touchRaw(std::uint16_t& x, std::uint16_t& y, std::uint16_t& z) {
    return readTouchRaw(x, y, z);
}

void loop() {
    if (pageChangePending) {
        pageChangePending = false;
        Page target = requestedPage;
        // First boot with a touch panel that was never calibrated: calibrate once, the knob skips.
        if (!bootChecked) {
            bootChecked = true;
            const app::Settings& config = app::settings();
            if (!config.touchValid && !config.touchSkipped && target != Page::TouchCal) {
                returnPage = target;
                target = Page::TouchCal;
            }
        }
        if (target != Page::Menu && target != Page::TouchCal) {
            returnPage = target;
        }
        enterPage(target);
    }

    const std::uint32_t now = millis();
    if (currentPage == Page::TouchCal) {
        serviceCalibration(now);
        if (pollButton() != Press::None) {
            onShortPress();
        }
        takeEncoderSteps();
        return;
    }

    pollTouch(now);

    const int steps = takeEncoderSteps();
    if (steps != 0) {
        onRotate(steps);
        dirty = true;
    }

    switch (pollButton()) {
        case Press::Short:
            onShortPress();
            dirty = true;
            break;
        case Press::Long:
            if (currentPage != Page::Menu) {
                goHome();
            }
            break;
        default:
            break;
    }

    if (dirty || now - lastRefreshMs >= kRefreshMs) {
        lastRefreshMs = now;
        dirty = false;
        renderPage();
    }
}

}  // namespace ui
